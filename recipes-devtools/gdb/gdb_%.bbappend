# Enable GDB features
# See https://git.yoctoproject.org/poky/plain/meta/recipes-devtools/gdb/gdb-common.inc
PACKAGECONFIG:append = " python tui xz"
